# Autodesk Inventor part: Base
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2019-10
Part Number: Base
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Base
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
